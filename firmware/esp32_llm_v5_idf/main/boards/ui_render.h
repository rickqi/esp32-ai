/*
 * ui_render.h — RLCD text rendering (5x7 ASCII + 14x14 CJK) for V5 IDF.
 *
 * Port of Arduino esp32_llm_zh_v5/display.h text layer onto the IDF
 * DisplayPort (ST7305 400x300 1bpp, PSRAM framebuffer + LUT).
 *
 * Provides:
 *   ui_text(x, y, utf8_str)        — draw UTF-8 string at (x,y)
 *   ui_clear_rect / ui_fill_rect   — area ops
 *   ui_show()                      — flush framebuffer to panel
 *
 * Fonts: 5x7 ASCII (RLCD_FONT, 256 glyphs) + 14x14 CJK (cjk_font.h, 7854 glyphs).
 * Missing CJK glyphs render as a hollow 14x14 box (□).
 */
#ifndef UI_RENDER_H
#define UI_RENDER_H

#include <stdint.h>
#include <string.h>
#include "display_bsp.h"
#include "cjk_font.h"

#ifdef __cplusplus
extern "C" {
#endif

// glyph metrics
#define UI_CW      6      // 5x7 ASCII cell width  (5 + 1 gap)
#define UI_CH      8      // 5x7 ASCII glyph height (8 rows)
#define UI_CJK_W   14     // CJK glyph width
#define UI_CJK_H   14     // CJK glyph height
#define UI_ROW_H   14     // row height (CJK), ASCII vertically centered

// ---- 5x7 ASCII font (256 glyphs x 5 bytes, MSB=top) ----------------------
// Copied verbatim from esp32_llm_zh_v3/display.h RLCD_FONT (works on device).
static const uint8_t UI_FONT_5X7[] = {
  0x00,0x00,0x00,0x00,0x00,0x3E,0x5B,0x4F,0x5B,0x3E,
  0x3E,0x6B,0x4F,0x6B,0x3E,0x1C,0x3E,0x7C,0x3E,0x1C,
  0x18,0x3C,0x7E,0x3C,0x18,0x1C,0x57,0x7D,0x57,0x1C,
  0x1C,0x5E,0x7F,0x5E,0x1C,0x00,0x18,0x3C,0x18,0x00,
  0xFF,0xE7,0xC3,0xE7,0xFF,0x00,0x18,0x24,0x18,0x00,
  0xFF,0xE7,0xDB,0xE7,0xFF,0x30,0x48,0x3A,0x06,0x0E,
  0x26,0x29,0x79,0x29,0x26,0x40,0x7F,0x05,0x05,0x07,
  0x40,0x7F,0x05,0x25,0x3F,0x5A,0x3C,0xE7,0x3C,0x5A,
  0x7F,0x3E,0x1C,0x1C,0x08,0x08,0x1C,0x1C,0x3E,0x7F,
  0x14,0x22,0x7F,0x22,0x14,0x5F,0x5F,0x00,0x5F,0x5F,
  0x06,0x09,0x7F,0x01,0x7F,0x00,0x66,0x89,0x95,0x6A,
  0x60,0x60,0x60,0x60,0x60,0x94,0xA2,0xFF,0xA2,0x94,
  0x08,0x04,0x7E,0x04,0x08,0x10,0x20,0x7E,0x20,0x10,
  0x08,0x08,0x2A,0x1C,0x08,0x08,0x1C,0x2A,0x08,0x08,
  0x1E,0x10,0x10,0x10,0x10,0x0C,0x1E,0x0C,0x1E,0x0C,
  0x30,0x38,0x3E,0x38,0x30,0x06,0x0E,0x3E,0x0E,0x06,
  0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x5F,0x00,0x00,
  0x00,0x07,0x00,0x07,0x00,0x14,0x7F,0x14,0x7F,0x14,
  0x24,0x2A,0x7F,0x2A,0x12,0x23,0x13,0x08,0x64,0x62,
  0x36,0x49,0x56,0x20,0x50,0x00,0x08,0x07,0x03,0x00,
  0x00,0x1C,0x22,0x41,0x00,0x00,0x41,0x22,0x1C,0x00,
  0x2A,0x1C,0x7F,0x1C,0x2A,0x08,0x08,0x3E,0x08,0x08,
  0x00,0x80,0x70,0x30,0x00,0x08,0x08,0x08,0x08,0x08,
  0x00,0x00,0x60,0x60,0x00,0x20,0x10,0x08,0x04,0x02,
  0x3E,0x51,0x49,0x45,0x3E,0x00,0x42,0x7F,0x40,0x00,
  0x72,0x49,0x49,0x49,0x46,0x21,0x41,0x49,0x4D,0x33,
  0x18,0x14,0x12,0x7F,0x10,0x27,0x45,0x45,0x45,0x39,
  0x3C,0x4A,0x49,0x49,0x31,0x41,0x21,0x11,0x09,0x07,
  0x36,0x49,0x49,0x49,0x36,0x46,0x49,0x49,0x29,0x1E,
  0x00,0x00,0x14,0x00,0x00,0x00,0x40,0x34,0x00,0x00,
  0x00,0x08,0x14,0x22,0x41,0x14,0x14,0x14,0x14,0x14,
  0x00,0x41,0x22,0x14,0x08,0x02,0x01,0x59,0x09,0x06,
  0x3E,0x41,0x5D,0x59,0x4E,0x7C,0x12,0x11,0x12,0x7C,
  0x7F,0x49,0x49,0x49,0x36,0x3E,0x41,0x41,0x41,0x22,
  0x7F,0x41,0x41,0x41,0x3E,0x7F,0x49,0x49,0x49,0x41,
  0x7F,0x09,0x09,0x09,0x01,0x3E,0x41,0x41,0x51,0x73,
  0x7F,0x08,0x08,0x08,0x7F,0x00,0x41,0x7F,0x41,0x00,
  0x20,0x40,0x41,0x3F,0x01,0x7F,0x08,0x14,0x22,0x41,
  0x7F,0x40,0x40,0x40,0x40,0x7F,0x02,0x1C,0x02,0x7F,
  0x7F,0x04,0x08,0x10,0x7F,0x3E,0x41,0x41,0x41,0x3E,
  0x7F,0x09,0x09,0x09,0x06,0x3E,0x41,0x51,0x21,0x5E,
  0x7F,0x09,0x19,0x29,0x46,0x26,0x49,0x49,0x49,0x32,
  0x03,0x01,0x7F,0x01,0x03,0x3F,0x40,0x40,0x40,0x3F,
  0x1F,0x20,0x40,0x20,0x1F,0x3F,0x40,0x38,0x40,0x3F,
  0x63,0x14,0x08,0x14,0x63,0x03,0x04,0x78,0x04,0x03,
  0x61,0x59,0x49,0x4D,0x43,0x00,0x7F,0x41,0x41,0x41,
  0x02,0x04,0x08,0x10,0x20,0x00,0x41,0x41,0x41,0x7F,
  0x04,0x02,0x01,0x02,0x04,0x40,0x40,0x40,0x40,0x40,
  0x00,0x03,0x07,0x08,0x00,0x20,0x54,0x54,0x78,0x40,
  0x7F,0x28,0x44,0x44,0x38,0x38,0x44,0x44,0x44,0x28,
  0x38,0x44,0x44,0x28,0x7F,0x38,0x54,0x54,0x54,0x18,
  0x00,0x08,0x7E,0x09,0x02,0x18,0xA4,0xA4,0x9C,0x78,
  0x7F,0x08,0x04,0x04,0x78,0x00,0x44,0x7D,0x40,0x00,
  0x20,0x40,0x40,0x3D,0x00,0x7F,0x10,0x28,0x44,0x00,
  0x00,0x41,0x7F,0x40,0x00,0x7C,0x04,0x78,0x04,0x78,
  0x7C,0x08,0x04,0x04,0x78,0x38,0x44,0x44,0x44,0x38,
  0xFC,0x18,0x24,0x24,0x18,0x18,0x24,0x24,0x18,0xFC,
  0x7C,0x08,0x04,0x04,0x08,0x48,0x54,0x54,0x54,0x24,
  0x04,0x04,0x3F,0x44,0x24,0x3C,0x40,0x40,0x20,0x7C,
  0x1C,0x20,0x40,0x20,0x1C,0x3C,0x40,0x30,0x40,0x3C,
  0x44,0x28,0x10,0x28,0x44,0x4C,0x90,0x90,0x90,0x7C,
  0x44,0x64,0x54,0x4C,0x44,0x00,0x08,0x36,0x41,0x00,
  0x00,0x00,0x77,0x00,0x00,0x00,0x41,0x36,0x08,0x00,
  0x02,0x01,0x02,0x04,0x02,0x3C,0x26,0x23,0x26,0x3C,
  0x1E,0xA1,0xA1,0x61,0x12,0x3A,0x40,0x40,0x20,0x7A,
  0x38,0x54,0x54,0x55,0x59,0x21,0x55,0x55,0x79,0x41,
  0x22,0x54,0x54,0x78,0x42,0x21,0x55,0x54,0x78,0x40,
  0x20,0x54,0x55,0x79,0x40,0x0C,0x1E,0x52,0x72,0x12,
  0x39,0x55,0x55,0x55,0x59,0x39,0x54,0x54,0x54,0x59,
  0x39,0x55,0x54,0x54,0x58,0x00,0x00,0x45,0x7C,0x41,
  0x00,0x02,0x45,0x7D,0x42,0x00,0x01,0x45,0x7C,0x40,
  0x7D,0x12,0x11,0x12,0x7D,0xF0,0x28,0x25,0x28,0xF0,
  0x7C,0x54,0x55,0x45,0x00,0x20,0x54,0x54,0x7C,0x54,
  0x7C,0x0A,0x09,0x7F,0x49,0x32,0x49,0x49,0x49,0x32,
  0x3A,0x44,0x44,0x44,0x3A,0x32,0x4A,0x48,0x48,0x30,
  0x3A,0x41,0x41,0x21,0x7A,0x3A,0x42,0x40,0x20,0x78,
  0x00,0x9D,0xA0,0xA0,0x7D,0x3D,0x42,0x42,0x42,0x3D,
  0x3D,0x40,0x40,0x40,0x3D,0x3C,0x24,0xFF,0x24,0x24,
  0x48,0x7E,0x49,0x43,0x66,0x2B,0x2F,0xFC,0x2F,0x2B,
  0xFF,0x09,0x29,0xF6,0x20,0xC0,0x88,0x7E,0x09,0x03,
  0x20,0x54,0x54,0x79,0x41,0x00,0x00,0x44,0x7D,0x41,
  0x30,0x48,0x48,0x4A,0x32,0x38,0x40,0x40,0x22,0x7A,
  0x00,0x7A,0x0A,0x0A,0x72,0x7D,0x0D,0x19,0x31,0x7D,
  0x26,0x29,0x29,0x2F,0x28,0x26,0x29,0x29,0x29,0x26,
  0x30,0x48,0x4D,0x40,0x20,0x38,0x08,0x08,0x08,0x08,
  0x08,0x08,0x08,0x08,0x38,0x2F,0x10,0xC8,0xAC,0xBA,
  0x2F,0x10,0x28,0x34,0xFA,0x00,0x00,0x7B,0x00,0x00,
  0x08,0x14,0x2A,0x14,0x22,0x22,0x14,0x2A,0x14,0x08,
  0x55,0x00,0x55,0x00,0x55,0xAA,0x55,0xAA,0x55,0xAA,
  0xFF,0x55,0xFF,0x55,0xFF,0x00,0x00,0x00,0xFF,0x00,
  0x10,0x10,0x10,0xFF,0x00,0x14,0x14,0x14,0xFF,0x00,
  0x10,0x10,0xFF,0x00,0xFF,0x10,0x10,0xF0,0x10,0xF0,
  0x14,0x14,0x14,0xFC,0x00,0x14,0x14,0xF7,0x00,0xFF,
  0x00,0x00,0xFF,0x00,0xFF,0x14,0x14,0xF4,0x04,0xFC,
  0x14,0x14,0x17,0x10,0x1F,0x10,0x10,0x1F,0x10,0x1F,
  0x14,0x14,0x14,0x1F,0x00,0x10,0x10,0x10,0xF0,0x00,
  0x00,0x00,0x00,0x1F,0x10,0x10,0x10,0x10,0x1F,0x10,
  0x10,0x10,0x10,0xF0,0x10,0x00,0x00,0x00,0xFF,0x10,
  0x10,0x10,0x10,0x10,0x10,0x10,0x10,0x10,0xFF,0x10,
  0x00,0x00,0x00,0xFF,0x14,0x00,0x00,0xFF,0x00,0xFF,
  0x00,0x00,0x1F,0x10,0x17,0x00,0x00,0xFC,0x04,0xF4,
  0x14,0x14,0x17,0x10,0x17,0x14,0x14,0xF4,0x04,0xF4,
  0x00,0x00,0xFF,0x00,0xF7,0x14,0x14,0x14,0x14,0x14,
  0x14,0x14,0xF7,0x00,0xF7,0x14,0x14,0x14,0x17,0x14,
  0x10,0x10,0x1F,0x10,0x1F,0x14,0x14,0x14,0xF4,0x14,
  0x10,0x10,0xF0,0x10,0xF0,0x00,0x00,0x1F,0x10,0x1F,
  0x00,0x00,0x00,0x1F,0x14,0x00,0x00,0x00,0xFC,0x14,
  0x00,0x00,0xF0,0x10,0xF0,0x10,0x10,0xFF,0x10,0xFF,
  0x14,0x14,0x14,0xFF,0x14,0x10,0x10,0x10,0x1F,0x00,
  0x00,0x00,0x00,0xF0,0x10,0xFF,0xFF,0xFF,0xFF,0xFF,
  0xF0,0xF0,0xF0,0xF0,0xF0,0xFF,0xFF,0xFF,0x00,0x00,
  0x00,0x00,0x00,0xFF,0xFF,0x0F,0x0F,0x0F,0x0F,0x0F,
  0x38,0x44,0x44,0x38,0x44,0xFC,0x4A,0x4A,0x4A,0x34,
  0x7E,0x02,0x02,0x06,0x06,0x02,0x7E,0x02,0x7E,0x02,
  0x63,0x55,0x49,0x41,0x63,0x38,0x44,0x44,0x3C,0x04,
  0x40,0x7E,0x20,0x1E,0x20,0x06,0x02,0x7E,0x02,0x02,
  0x99,0xA5,0xE7,0xA5,0x99,0x1C,0x2A,0x49,0x2A,0x1C,
  0x4C,0x72,0x01,0x72,0x4C,0x30,0x4A,0x4D,0x4D,0x30,
  0x30,0x48,0x78,0x48,0x30,0xBC,0x62,0x5A,0x46,0x3D,
  0x3E,0x49,0x49,0x49,0x00,0x7E,0x01,0x01,0x01,0x7E,
  0x2A,0x2A,0x2A,0x2A,0x2A,0x44,0x44,0x5F,0x44,0x44,
  0x40,0x51,0x4A,0x44,0x40,0x40,0x44,0x4A,0x51,0x40,
  0x00,0x00,0xFF,0x01,0x03,0xE0,0x80,0xFF,0x00,0x00,
  0x08,0x08,0x6B,0x6B,0x08,0x36,0x12,0x36,0x24,0x36,
  0x06,0x0F,0x09,0x0F,0x06,0x00,0x00,0x18,0x18,0x00,
  0x00,0x00,0x10,0x10,0x00,0x30,0x40,0xFF,0x01,0x01,
  0x00,0x1F,0x01,0x01,0x1E,0x00,0x19,0x1D,0x17,0x12,
  0x00,0x3C,0x3C,0x3C,0x3C,0x00,0x00,0x00,0x00,0x00,
};

// ---- UTF-8 decode (returns codepoint, sets *consumed) ---------------------
static inline int ui_utf8_decode(const unsigned char *s, int len, int *consumed) {
  unsigned char b0 = s[0];
  if (b0 < 0x80) { *consumed = 1; return b0; }
  if ((b0 & 0xE0) == 0xC0 && len >= 2) {
    *consumed = 2;
    return ((b0 & 0x1F) << 6) | (s[1] & 0x3F);
  }
  if ((b0 & 0xF0) == 0xE0 && len >= 3) {
    *consumed = 3;
    return ((b0 & 0x0F) << 12) | ((s[1] & 0x3F) << 6) | (s[2] & 0x3F);
  }
  *consumed = 1;
  return -1;
}

// ---- binary search CJK_CP -> glyph index ----------------------------------
static inline int ui_cjk_find(int cp) {
  int lo = 0, hi = CJK_N - 1;
  while (lo <= hi) {
    int mid = (lo + hi) >> 1;
    if (CJK_CP[mid] < cp) lo = mid + 1;
    else if (CJK_CP[mid] > cp) hi = mid - 1;
    else return mid;
  }
  return -1;
}

// ---- draw one 5x7 ASCII glyph at (x,y) ------------------------------------
static inline void ui_draw_char(DisplayPort *d, int x, int y, unsigned char c) {
  const uint8_t *g = &UI_FONT_5X7[(unsigned)c * 5];
  for (int col = 0; col < 5; col++) {
    uint8_t bits = g[col];
    for (int row = 0; row < 8; row++)
      if (bits & (1 << row)) d->RLCD_SetPixel(x + col, y + row, ColorBlack);
  }
}

// ---- draw one 14x14 CJK glyph at (x,y), missing -> hollow box -------------
static inline void ui_draw_cjk(DisplayPort *d, int x, int y, int cp) {
  int idx = ui_cjk_find(cp);
  if (idx < 0) {   // missing glyph: 2px border box
    for (int i = 0; i < UI_CJK_W; i++) {
      d->RLCD_SetPixel(x + i, y, ColorBlack);
      d->RLCD_SetPixel(x + i, y + UI_CJK_H - 1, ColorBlack);
    }
    for (int j = 0; j < UI_CJK_H; j++) {
      d->RLCD_SetPixel(x, y + j, ColorBlack);
      d->RLCD_SetPixel(x + UI_CJK_W - 1, y + j, ColorBlack);
    }
    return;
  }
  const uint8_t *g = &CJK_BLOB[CJK_OFF[idx]];
  for (int row = 0; row < UI_CJK_H; row++) {
    for (int col = 0; col < UI_CJK_W; col++) {
      if (g[row * 2 + col / 8] & (0x80 >> (col % 8)))
        d->RLCD_SetPixel(x + col, y + row, ColorBlack);
    }
  }
}

// ---- draw UTF-8 string at (x,y), no wrap ----------------------------------
static inline int ui_text(DisplayPort *d, int x, int y, const char *s) {
  int cx = x;
  const unsigned char *p = (const unsigned char *)s;
  while (*p) {
    int consumed;
    int cp = ui_utf8_decode(p, 8, &consumed);
    if (cp < 0) { p++; continue; }
    if (cp == '\n') { y += UI_ROW_H; cx = x; }
    else if (cp >= 32 && cp < 0x80) {
      ui_draw_char(d, cx, y + (UI_ROW_H - UI_CH) / 2, (unsigned char)cp);
      cx += UI_CW;
    } else if (cp >= 0x80) {
      ui_draw_cjk(d, cx, y, cp);
      cx += UI_CJK_W;
    }
    p += consumed;
  }
  return cx - x;   // consumed width
}

// ---- clear rectangle to white ---------------------------------------------
static inline void ui_clear_rect(DisplayPort *d, int x0, int y0, int x1, int y1) {
  for (int y = y0; y <= y1; y++)
    for (int x = x0; x <= x1; x++)
      d->RLCD_SetPixel(x, y, ColorWhite);
}

// ---- fill rectangle black --------------------------------------------------
static inline void ui_fill_rect(DisplayPort *d, int x0, int y0, int x1, int y1) {
  for (int y = y0; y <= y1; y++)
    for (int x = x0; x <= x1; x++)
      d->RLCD_SetPixel(x, y, ColorBlack);
}

// ---- inverted primitives (white on black, for inverted bars) ---------------
static inline void ui_fill_rect_inv(DisplayPort *d, int x0, int y0, int x1, int y1) {
  for (int y = y0; y <= y1; y++)
    for (int x = x0; x <= x1; x++)
      d->RLCD_SetPixel(x, y, ColorWhite);
}

static inline void ui_draw_char_inv(DisplayPort *d, int x, int y, unsigned char c) {
  const uint8_t *g = &UI_FONT_5X7[(unsigned)c * 5];
  for (int col = 0; col < 5; col++) {
    uint8_t bits = g[col];
    for (int row = 0; row < 8; row++)
      if (bits & (1 << row)) d->RLCD_SetPixel(x + col, y + row, ColorWhite);
  }
}

static inline void ui_text_inv(DisplayPort *d, int x, int y, const char *s) {
  int cx = x;
  while (*s) {
    char c = *s++;
    if (c >= 32 && c < 127) { ui_draw_char_inv(d, cx, y, (unsigned char)c); cx += UI_CW; }
  }
}

// ---- 2x font (each pixel → 2×2 block) for prominent text -------------------
#define UI_CW2 12   // 2x char cell width  (5*2 + 2 gap)
#define UI_CH2 14   // 2x char cell height (7*2)

static inline void ui_draw_char_2x(DisplayPort *d, int x, int y, unsigned char c) {
  const uint8_t *g = &UI_FONT_5X7[(unsigned)c * 5];
  for (int col = 0; col < 5; col++) {
    uint8_t bits = g[col];
    for (int row = 0; row < 7; row++) {
      if (bits & (1 << row)) {
        d->RLCD_SetPixel(x+col*2,   y+row*2,   ColorBlack);
        d->RLCD_SetPixel(x+col*2+1, y+row*2,   ColorBlack);
        d->RLCD_SetPixel(x+col*2,   y+row*2+1, ColorBlack);
        d->RLCD_SetPixel(x+col*2+1, y+row*2+1, ColorBlack);
      }
    }
  }
}

static inline void ui_draw_char_2x_inv(DisplayPort *d, int x, int y, unsigned char c) {
  const uint8_t *g = &UI_FONT_5X7[(unsigned)c * 5];
  for (int col = 0; col < 5; col++) {
    uint8_t bits = g[col];
    for (int row = 0; row < 7; row++) {
      if (bits & (1 << row)) {
        d->RLCD_SetPixel(x+col*2,   y+row*2,   ColorWhite);
        d->RLCD_SetPixel(x+col*2+1, y+row*2,   ColorWhite);
        d->RLCD_SetPixel(x+col*2,   y+row*2+1, ColorWhite);
        d->RLCD_SetPixel(x+col*2+1, y+row*2+1, ColorWhite);
      }
    }
  }
}

static inline void ui_text_2x(DisplayPort *d, int x, int y, const char *s) {
  int cx = x;
  while (*s) {
    char c = *s++;
    if (c >= 32 && c < 127) { ui_draw_char_2x(d, cx, y, (unsigned char)c); cx += UI_CW2; }
  }
}

static inline void ui_text_2x_inv(DisplayPort *d, int x, int y, const char *s) {
  int cx = x;
  while (*s) {
    char c = *s++;
    if (c >= 32 && c < 127) { ui_draw_char_2x_inv(d, cx, y, (unsigned char)c); cx += UI_CW2; }
  }
}

// ---- BORDER_W-pixel thick rectangle frame ----------------------------------
#define UI_BORDER_W 2

static inline void ui_draw_rect(DisplayPort *d, int x0, int y0, int x1, int y1) {
  for (int w = 0; w < UI_BORDER_W; w++) {
    int L = x0 + w, R = x1 - w, T = y0 + w, B = y1 - w;
    for (int x = L; x <= R; x++) { d->RLCD_SetPixel(x, T, ColorBlack); d->RLCD_SetPixel(x, B, ColorBlack); }
    for (int y = T; y <= B; y++) { d->RLCD_SetPixel(L, y, ColorBlack); d->RLCD_SetPixel(R, y, ColorBlack); }
  }
}

// ---- horizontal separator line ----------------------------------------------
static inline void ui_hline(DisplayPort *d, int y, int x0, int x1) {
  for (int x = x0; x <= x1; x++) d->RLCD_SetPixel(x, y, ColorBlack);
}

#ifdef __cplusplus
}
#endif

#endif
